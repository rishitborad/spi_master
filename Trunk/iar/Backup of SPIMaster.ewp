# IAR project Backup of SPIMaster.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX
  ICCARM.CCIncludePath2: ..\include; ..\..\RtosSalvo\Inc; ..\src\board; ..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPIMaster.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\src\board\stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration IAR_Board (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; IAR_BOARD
  group (top)
    ../include/: dmu.h
    ../src/: main.c
    ../src/timer/: timer.c
  group board
    ../include/: boardDefinition.h
    ../src/board/: bsp.c ConfigureGPIOPins.c iar_stm32f207zg_sk.c stm32f2xx_flash.icf
  group debug
    ../src/usart/: commandLine.c commands.c commands.h commandTable.c debug.c debug_usart.c
  group drivers
    ../src/spi/: spi.c
    ../src/timer/: SyncTimer.c
  group rtos
    ../src/rtos/: salvohook_idle.c salvohook_interrupt.c salvohook_wdt.c
  group Salvo
    ../../RtosSalvo/Iar/Debug/Exe/: salvo.a
    ../include/: salvocfg.h salvodefs.h
  group STM32F2xx_StdPeriph_Driver
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group STM32F2xx_StdPeriph_Driver/startup
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group user
    ../src/userProtocol/: comm_buffers.c
    ../src/spi/: UserCommunication_SPI.c
  group utilities
    ../src/utilities/: circbuf.c utilities.c
    ../include/: circbuf.h
